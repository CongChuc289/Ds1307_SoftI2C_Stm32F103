# Keil uVision project EXTI.uvprojx, settings and files
target EXTI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EXTI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\STM32F10x_StdPeriph_Driver\src;..\..\project;.\Library_t
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_i2c.c
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./: RING_BUFFER.c
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group Library_t
    ./Library_t/: DS1307.c DS1307.h Soft_I2C.c Soft_I2C.h TIMER.c TIMER.h CLOCK.c CLOCK.h USART.c USART.h
